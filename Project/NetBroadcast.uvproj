# Keil uVision project NetBroadcast.uvproj, settings and files
target NetBroadcast (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: NetBroadcast +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\Header;..\Lib\Header\inc\STM32F10x;..\Device;..\Tools
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group App
    ../App/: CanPro.c Config.c main.c NetPro.c Public.c VoicePro.c Udp.c
  group Hardware
    ../Hardware/: Can.c CPU.c FmInit.c Uart.c W5500.C SD2068.c
  group Device
    ../Device/: IPD_ZJM.c IPD_ZJM.h PekingPower.c PekingPower.h DeviceManger.c DeviceManger.h Switcher.c Switcher.h
  group Header
    ../Header/: Can.h CanPro.h Config.h Cpu.h FmInit.h Public.h sys.h Uart.h Voice.h VoicePro.h W5500.h Udp.h SD2068.h
  group Lib
    ../Lib/: sys.c stm32f10x_lib.c startup_stm32f10x_hd.s
